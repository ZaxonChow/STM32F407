#include "./modbus_rtu/bsp_master.h"

// CRC校验
//********************************************************************************************************************
const uint8_t auchCRCHi[] = { 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 
0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x9A, 0x28, 0xEA, 0x49,
0x8F, 0xF9, 0x41, 0x79, 0xFA}; 

const uint8_t auchCRCLo[] = { 
0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 
0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 
0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3, 
0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 
0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 
0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26, 
0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 
0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 
0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5, 
0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 
0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 
0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C, 
0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,0x43, 0x83, 0x41, 0x81, 0x80, 0x40, 0x9A, 0x69, 0xAB, 0xC8, 
0x8F, 0x41, 0xF9, 0x79, 0xFA};
//********************************************************************************************************************

/* 溶解氧读测量值指令
	*设备ID地址：0x01
	*功能码：0x03
	*寄存器起始地址：0x0001
	*寄存器数量：0x0002
	*CRC16：0xCB95	
*/
Command Ox_ReadValCmd = {0x01, 0x03, 0x00, 0x01, 0x00, 0x02, 0x95, 0xCB};

uint8_t RS485_RxFlag;
uint32_t RS485_RX_BUFF[20];		//接收缓冲区2048字节
uint16_t RS485_RX_CNT;

uint8_t  RS485_TX_BUFF[20];	//发送缓冲区
uint16_t RS485_TX_CNT = 0;		//发送计数器
uint8_t  RS485_TxFlag = 0;		//发送一帧结束标记

uint8_t State = 1;				//当前读取的传感器，1表示溶解氧，2表示ph
uint8_t Ox_State = 1;			//溶解氧传感器接收使能

/* CRC校验函数 */
//static uint16_t CRC_Compute(uint8_t* puchMsg, uint16_t usDataLen)
//{ 
//	uint8_t uchCRCHi = 0xFF ; 
//	uint8_t uchCRCLo = 0xFF ; 
//	uint32_t uIndex ; 
//	while(usDataLen--) 
//	{ 
//		uIndex = uchCRCHi ^ *puchMsg++ ; 
//		uchCRCHi = uchCRCLo ^ auchCRCHi[uIndex] ; 
//		uchCRCLo = auchCRCLo[uIndex] ; 
//	}
//	return ((uchCRCHi << 8)  | (uchCRCLo)) ; 
//}

/* 主机读测量值服务程序
	*根据设备ID地址，读取相应的检测数据
*/
void ReadVal_Service(uint8_t SlaverAddr)
{    
	switch(SlaverAddr)
	{
		case 01://读溶解氧
				Ox_Read_Val(&Ox_ReadValCmd);
				break;
	}		
}

/* 向溶解氧传感器发送读测量值指令 */
static void Ox_Read_Val(Command* Ox_Read_VAl_Cmd)
{ 
	RS485_TX_BUFF[0] = Ox_Read_VAl_Cmd->SlaverAddr;
	RS485_TX_BUFF[1] = Ox_Read_VAl_Cmd->FuctionNum;
	RS485_TX_BUFF[2] = Ox_Read_VAl_Cmd->AddrH;  
	RS485_TX_BUFF[3] = Ox_Read_VAl_Cmd->AddrL; 
	RS485_TX_BUFF[4] = Ox_Read_VAl_Cmd->QuantityH;
	RS485_TX_BUFF[5] = Ox_Read_VAl_Cmd->QuantityL;
	RS485_TX_BUFF[6] = Ox_Read_VAl_Cmd->CRCL;
	RS485_TX_BUFF[7] = Ox_Read_VAl_Cmd->CRCH;
	RS485_SendData(&RS485_TX_BUFF[0], 8);		//发送读测量值指令
}

/* 接收数据处理函数
	*根据从机设备 ID 地址，处理从机返回的数据
*/
void Receive_Service(void)
{
	//uint16_t calCRC = 0;	//存放接收数据计算后得到的 CRC 校验值
	//uint16_t recCRC;		//存放接收到的 CRC 校验值
	
	if(RS485_RxFlag == 1 &&							//确认接收一帧数据
		RS485_RX_BUFF[0] == RS485_TX_BUFF[0] &&		//地址正确
		RS485_RX_BUFF[1] == RS485_TX_BUFF[1])		//功能码正确
	{
		//CRC校验
		//calCRC = CRC_Compute(RS485_RX_BUFF, RS485_RX_CNT - 2);	//计算所接收数据的CRC
		//recCRC = RS485_RX_BUFF[RS485_RX_CNT-1] | (((uint16_t)RS485_RX_BUFF[RS485_RX_CNT-2]) << 8);//接收到的CRC(低字节在前，高字节在后)
		//if(calCRC == recCRC)//CRC校验正确
		//{
			switch(RS485_RX_BUFF[0])	//根据不同的设备 ID 地址进行处理
			{    
				case 01:
					Modbus_01_Solve();
					break;
			}													
		//}
	}                              
	RS485_RxFlag = 0;		//复位帧结束标志
	RS485_RX_CNT = 0;		//接收计数器清零
	_485_TX_EN();			//接收完成，开启发送模式  
}

/* 处理溶解氧传感器返回的数据
	*排除了寄存器的字节验证机制，采用默认的轮询周期清空缓存区
*/
void Modbus_01_Solve(void)
{
	float Ox_Value;
	uint32_t temp[1] = { 0 };
	//mx=*((float*)&xbuf[0])
	if(RS485_RxFlag)	//接收到了数据,且接收完成了
	{			
		RS485_RX_CNT = 0;	//清零接收数据计数
		//溶解氧
		temp[0] = ((RS485_RX_BUFF[5] << 24) | (RS485_RX_BUFF[6] << 16) | (RS485_RX_BUFF[3] << 8) | RS485_RX_BUFF[4]);
		printf("%2x %2x %2x %2x \r\n", RS485_RX_BUFF[5], RS485_RX_BUFF[6], RS485_RX_BUFF[3], RS485_RX_BUFF[4]);
		Ox_Value = *((float*)&temp[0]);		//将接收的数值转换为浮点型
		printf("Ox_Value = %.3f mg/L \r\n", Ox_Value);
	}
}

//通讯策略
void Modbus_RTU(void)   //TIM4 中断调用的
{	
	switch(State)		//根据模式，选择读取
	{
		case 1: //modbus执行命令第一步。
				//多次通讯结果可以按照类似的封装进行填写
				//向从机发送一个请求。发送命令完成，定时器T4处理接收到的数据
			if(Ox_State == 1)
			{
				ReadVal_Service(0x01);	//发送指令读取溶解氧
//				State = 2;				//切换到ph值传感器
//				ox_state = 0;
			}
//			else
//			{
//				ReadVal_Service(0x02);	//测ph
//				ox_state = 1;
//			}
			break;
		case 2:
			break;
	}
}



